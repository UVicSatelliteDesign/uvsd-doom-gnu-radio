options:
  parameters:
    generate_options: qt_gui
    id: DOOMflow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 625e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\miles\OneDrive\Desktop\Sat Stuff\GNU\DOOM\doom_gameplay.cfile
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.03'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import cv2

      class doom_4gfsk_decoder(gr.basic_block):
          def __init__(self, width=320, height=200, sync_header=b'\xDE\xAD\xBE\xEF'):
              gr.basic_block.__init__(self,
                  name="DOOM 4-GFSK Frame Decoder & Renderer",
                  in_sig=[np.float32], # Synchronized symbols from Symbol Sync
                  out_sig=None)

              self.WIDTH = width
              self.HEIGHT = height
              self.FRAME_BYTES = self.WIDTH * self.HEIGHT
              self.SYNC_HEADER = sync_header
              self.buffer = bytearray()
              
              # 4-Level Slicing Thresholds
              self.T1 = -0.66
              self.T2 = 0.0
              self.T3 = 0.66
              
              # Fast lookup table mapping the 4 levels to 2-bit pairs
              self.bit_table = np.array([
                  [0, 0],  # Level 0 (< T1)
                  [0, 1],  # Level 1 (T1 to T2)
                  [1, 0],  # Level 2 (T2 to T3)
                  [1, 1]   # Level 3 (>= T3)
              ], dtype=np.uint8)

          def general_work(self, input_items, output_items):
              in_symbols = input_items[0]
              symbols_consumed = len(in_symbols)

              if symbols_consumed == 0:
                  return 0

              # 1. Blazing fast vectorized slicing using NumPy (C-speed execution)
              bins = np.digitize(in_symbols, [self.T1, self.T2, self.T3])
              raw_bits = self.bit_table[bins].flatten()

              # 2. Pack bits into bytes and add to working buffer
              bit_array = np.packbits(raw_bits)
              self.buffer.extend(bit_array.tobytes())

              # 3. Frame Synchronization via Magic Header
              header_idx = self.buffer.find(self.SYNC_HEADER)
              if header_idx != -1:
                  del self.buffer[:header_idx + len(self.SYNC_HEADER)]

              # 4. Extract and Render Full Frames smoothly
              while len(self.buffer) >= self.FRAME_BYTES:
                  frame_raw = self.buffer[:self.FRAME_BYTES]
                  del self.buffer[:self.FRAME_BYTES]

                  # Reconstruct pixel array
                  img = np.frombuffer(frame_raw, dtype=np.uint8).reshape((self.HEIGHT, self.WIDTH))

                  # Upscale and display live window smoothly
                  display_frame = cv2.resize(img, (self.WIDTH * 3, self.HEIGHT * 3), interpolation=cv2.INTER_NEAREST)
                  cv2.imshow("DOOM 4-GFSK Live Feed", display_frame)
                  cv2.waitKey(1)

              self.consume(0, symbols_consumed)
              return symbols_consumed
    height: '240'
    sync_header: b'\xDE\xAD\xBE\xEF'
    width: '320'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Raw byte stream -> 4-GFSK modulator, as a GNU Radio Embedded Python Block (source, no inputs).

      Paste this whole file into a GRC "Python Block" and wire its complex output into your existing
      chain (Complex Low Pass Filter, decimation 1, ...). Remove the File Source / RTL-SDR Source.
      The block paces itself in real time, so a Throttle is not needed (an extra one is harmless).

      What it does
          Bytes arriving on the link are modulated exactly as received: 2 bits per symbol, MSB
          first, 00 -> -1, 01 -> -1/3, 10 -> +1/3, 11 -> +1 (times `deviation`), rectangular pulses.
          No commands, no framing, no header added. The SENDER puts the frame sync word
          (AA BB CC DD) in front of every frame, exactly as in the original design.
          When no data is waiting the block sends an unmodulated carrier, so the stream never stops.

      Link (port parameter; GRC passes it as typed, so 5558, "5558" and "tcp:5558" all mean TCP)
          "tcp:5558"             listen on 127.0.0.1:5558; a sender connects (doom_raw_sender.py)
          "COM7" / "/dev/ttyACM0" open that USB-serial port (a Pico running pico_raw_usb.py)
          The block stops reading when its buffer is full (max_buffer bytes, 0 = default 65536), so the sender is
          slowed to the real symbol rate by normal flow control (TCP window / USB).

      samp_rate / symbol_rate must be an integer. Single-threaded: the link is polled from work().
      """
      import select
      import socket
      import time

      import numpy as np
      from gnuradio import gr

      LEAD = 1024            # samples the engine may run ahead of the wall clock
      MIN_PRODUCE = 512
      MAX_PRODUCE = 1024
      UNIT_BYTES = 64        # bytes modulated per refill (64 bytes = 256 symbols = 1024 samples at 4 sps)
      IDLE_SYMS = 64


      class blk(gr.sync_block):
          def __init__(self, port="tcp:5558", samp_rate=2500000.0, symbol_rate=625000.0,
                       deviation=125000.0, gray=False, max_buffer=65536, realtime=False):
              gr.sync_block.__init__(self, name="Raw 4-GFSK Mod", in_sig=None,
                                     out_sig=[np.complex64])
              sps = float(samp_rate) / float(symbol_rate)
              if abs(sps - round(sps)) > 1e-9 or round(sps) < 1:
                  raise ValueError("samp_rate / symbol_rate must be an integer, got %r" % sps)
              self.sps = int(round(sps))
              self.fs = float(samp_rate)
              self.dev = float(deviation)
              # GRC passes parameters exactly as typed, so accept 5558, "5558" and "tcp:5558" as the
              # TCP port, and anything else ("COM7", "/dev/ttyACM0") as a serial port.
              p = str(port).strip().strip("'\"")
              if p.lower().startswith("tcp:"):
                  p = p[4:]
              self._tcp_port = int(p) if p.isdigit() else None
              self.port = p
              mb = int(max_buffer) if str(max_buffer).strip() else 0
              self.max_buffer = mb if mb > 0 else 65536        # 0 / blank = default
              self.realtime = str(realtime).strip().lower() in ("1", "true", "yes")

              lv = np.array([-1.0, -1.0 / 3.0, 1.0 / 3.0, 1.0])
              sym_to_level = np.array([0, 1, 3, 2]) if gray else np.array([0, 1, 2, 3])
              self.sym_freq = lv[sym_to_level]
              self._idle = np.zeros(IDLE_SYMS)

              self.buf = bytearray()
              self.iq = np.zeros(0, dtype=np.complex64)
              self.phase = 0.0
              self.t0 = None
              self.emitted = 0
              self.bytes_in = 0
              self.bytes_mod = 0
              self.idle_syms = 0

              self._conn = None
              self._srv = None
              self._ser = None
              if self._tcp_port is not None:
                  self._srv = socket.socket()
                  self._srv.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
                  self._srv.bind(("127.0.0.1", self._tcp_port))
                  self._srv.listen(1)
              else:
                  import serial
                  self._ser = serial.Serial(self.port, 115200, timeout=0)   # baud ignored by USB CDC
                  self._ser.reset_input_buffer()

          # ---------------- link ----------------
          def _poll_link(self, timeout):
              """Read whatever has arrived (never blocks longer than `timeout` seconds)."""
              room = self.max_buffer - len(self.buf)
              if self._ser is not None:
                  deadline = time.perf_counter() + max(0.0, timeout)
                  while True:
                      room = self.max_buffer - len(self.buf)
                      try:
                          n = self._ser.in_waiting if room > 0 else 0
                          if n:
                              d = self._ser.read(min(n, room))
                              self.buf += d
                              self.bytes_in += len(d)
                      except Exception as e:
                          print("[Raw 4-GFSK Mod] serial error:", e)
                          return
                      if time.perf_counter() >= deadline:
                          return
                      time.sleep(0.0002)
              socks = [self._srv] + ([self._conn] if self._conn is not None and room > 0 else [])
              try:
                  ready, _, _ = select.select(socks, [], [], max(0.0, timeout))
              except (OSError, ValueError):
                  return
              for sk in ready:
                  if sk is self._srv:
                      c, _ = sk.accept()
                      if self._conn is not None:
                          self._conn.close()
                      self._conn = c
                      self.buf.clear()
                      continue
                  try:
                      d = sk.recv(min(65536, room))
                  except OSError:
                      d = b""
                  if not d:
                      sk.close()
                      self._conn = None
                      continue
                  self.buf += d
                  self.bytes_in += len(d)

          # ---------------- modulator ----------------
          def _next_levels(self):
              if self.buf:
                  data = bytes(self.buf[:UNIT_BYTES])
                  del self.buf[:UNIT_BYTES]
                  self.bytes_mod += len(data)
                  bits = np.unpackbits(np.frombuffer(data, dtype=np.uint8))
                  sym = (bits[0::2].astype(np.int64) << 1) | bits[1::2]
                  return self.sym_freq[sym]
              self.idle_syms += IDLE_SYMS
              return self._idle                       # unmodulated carrier while no data waits

          def _refill(self, target):
              while self.iq.size < target:
                  freq = np.repeat(self._next_levels(), self.sps) * self.dev
                  phase = self.phase + 2.0 * np.pi * np.cumsum(freq) / self.fs
                  self.phase = float(phase[-1] % (2.0 * np.pi))
                  iq = np.exp(1j * np.mod(phase, 2.0 * np.pi)).astype(np.complex64)
                  self.iq = np.concatenate((self.iq, iq))

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              if not self.realtime:                       # free-running: the Throttle sets the rate
                  self._poll_link(0.0)
                  k = min(n, 8192)
                  self._refill(k)
                  out[:k] = self.iq[:k]
                  self.iq = self.iq[k:]
                  self.emitted += k
                  return k
              if self.t0 is None:
                  self.t0 = time.perf_counter() - LEAD / self.fs
              while True:
                  self._poll_link(0.0)
                  now = time.perf_counter()
                  allowed = int((now - self.t0) * self.fs) + LEAD - self.emitted
                  if allowed > LEAD + 4 * MAX_PRODUCE:          # fell behind: drop the lag
                      self.t0 = now - self.emitted / self.fs
                      allowed = LEAD
                  if allowed >= MIN_PRODUCE:
                      break
                  self._poll_link((MIN_PRODUCE - allowed) / self.fs)   # real-time wait that also reads the link
              k = max(1, min(n, MAX_PRODUCE, allowed))
              self._refill(k)
              out[:k] = self.iq[:k]
              self.iq = self.iq[k:]
              self.emitted += k
              return k

          def stop(self):
              for sk in (self._conn, self._srv, self._ser):
                  try:
                      if sk is not None:
                          sk.close()
                  except Exception:
                      pass
              print("[Raw 4-GFSK Mod] bytes in %d, modulated %d, idle %.2f s"
                    % (self.bytes_in, self.bytes_mod, self.idle_syms / (self.fs / self.sps)))
              return True
    deviation: fsk_deviation_hz
    gray: 'False'
    max_buffer: '65536'
    port: '5558'
    realtime: 'False'
    samp_rate: samp_rate
    symbol_rate: sym_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 400e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 400e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 2.5*fsk_deviation_hz
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', zeromq_pub_sink_0, '0']
- [epy_block_2, '0', blocks_throttle2_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
